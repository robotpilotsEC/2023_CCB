# Keil uVision project MY_ENGINEER.uvprojx, settings and files
target MY_ENGINEER (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MY_ENGINEER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT = 1U,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Drivers/CMSIS/Include;  .\USER\Alog;  .\USER\config;  .\USER\control;  .\USER\device;  .\USER\drive;  .\USER\motor;  .\USER\my_task;  .\USER\protocol;  .\USER\device\Imu;  ..\Drivers\CMSIS\DSP\Include;  .\USER\protocol\crc;  .\USER\Alog\support;  .\USER\cmsis
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Alog
    ./USER/Alog/: ave_filter.c rp_math.h
    ./USER/Alog/support/: math_support.c
  group drive
    ./USER/drive/: drive.c drv_io.c drv_can.c drv_uart.c drv_haltick.c
  group motor
    ./USER/motor/: motor.c MOTOR_EXAMPLE.c
  group device
    ./USER/device/: device.c flip_motor.c sucker_motor.c protract_motor.c transverse_motor.c pneumatic_motor.c remote.c
  group config
    ./USER/config/: config_uart.c config_can.c config.h
  group protocol
    ./USER/protocol/: can_protocol.c vision_protocol.c remote_protocol.c communicate_protocol.c judge_protocol.c my_judge.c
    ./USER/protocol/crc/: crc.c
  group control
    ./USER/control/: control.c car_state.c custom_control.c exchanges_control.c enter_mode_control.c flip.c uplift.c gimbal.c rescue.c sucker.c protract.c transverse.c pneumatic.c
  group my_task
    ./USER/my_task/: my_task.c
  group imu
    ./USER/device/Imu/: bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c soft_iic.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c iwdg.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ./USER/cmsis/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
